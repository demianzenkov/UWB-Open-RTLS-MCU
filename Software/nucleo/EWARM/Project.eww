<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\NUCLEOF207-RTLS.ewp</path>
  </project>
  <batchBuild />
</workspace>
