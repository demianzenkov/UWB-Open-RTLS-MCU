# IAR project tag.ewp, settings and files
configuration tag (ARM, debug)
  General.OGChipSelectEditMenu: STM32L072CB ST STM32L072CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L072xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0; ../Middlewares/Third_Party/Nanopb; ../User; ../User/Modules; ../User/Tasks; ../User/Proto; ../User/BSP; ../User/Decawave/platform; ../User/Decawave/decadriver; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../../proto
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..//Inc
  OBJCOPY.OOCOutputFile: tag.hex
  ILINK.IlinkOutputFile: tag.out
  ILINK.IlinkIcfFile: stm32l072xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l072xx.s
  group Application/User
    ../Src/: freertos.c main.c main.cpp stm32l0xx_hal_msp.c stm32l0xx_hal_timebase_tim.c stm32l0xx_it.c
  group Application/User/bsp
    ../User/BSP/: bsp_nvm.cpp bsp_os.cpp
  group Application/User/decawave/driver
    ../User/Decawave/decadriver/: deca_device.c deca_device_api.h deca_param_types.h deca_params_init.c deca_regs.h deca_types.h deca_version.h
  group Application/User/decawave/platform
    ../User/Decawave/platform/: deca_mutex.c deca_port.c deca_port.h deca_range_tables.c deca_sleep.c deca_spi.c deca_spi.h sleep.h
  group Application/User/modules
    ../User/Modules/: dwm1000.cpp lsm6.cpp lsm6ds3tr_c_reg.c settings.cpp tm_stm32_ahrs_imu.c une_tdoa.cpp une_twr.cpp wake.cpp
  group Application/User/proto
    ../../proto/: Monitoring.pb.c Settings.pb.c
    ../User/Proto/: monitoring_pb.cpp settings_pb.cpp virtual_pb.cpp
  group Application/User/tasks
    ../User/Tasks/: tsk_dwm.cpp tsk_event.cpp tsk_lsm.cpp tsk_usb.cpp
  group Application/User/usb
    ../Src/: usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_ll_usb.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group Middlewares/Nanopb
    ../Middlewares/Third_Party/Nanopb/: pb_common.c pb_decode.c pb_encode.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
