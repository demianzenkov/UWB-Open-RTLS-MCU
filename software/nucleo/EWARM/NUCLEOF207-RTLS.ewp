# IAR project NUCLEOF207-RTLS.ewp, settings and files
configuration NUCLEOF207-RTLS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F207xx; IS_ANCHOR
  ICCARM.CCIncludePath2: ../Inc; ../Inc/config/; ../Inc/modules/; ../Inc/modules/lwip; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Drivers/STM32F2xx_HAL_Driver/Inc; ../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Drivers/CMSIS/Device/ST/STM32F2xx/Include; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/posix; ../Middlewares/Third_Party/LwIP/src/include/posix/sys; ../Middlewares/Third_Party/LwIP/system/arch; ../Drivers/CMSIS/Include; ../Inc/tasks; ../Middlewares/Third_Party/Decawave/compiler; ../Middlewares/Third_Party/Decawave/decadriver; ../Middlewares/Third_Party/Decawave/platform
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\\Inc
  OBJCOPY.OOCOutputFile: NUCLEOF207-RTLS.hex
  ILINK.IlinkOutputFile: NUCLEOF207-RTLS.out
  ILINK.IlinkIcfFile: stm32f207xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Config
    ../Inc/config/: bsp_conf.h
    ../Src/config/: net_conf.cpp
  group Application/EWARM
    ./: startup_stm32f207xx.s
  group Application/Modules
    ../Src/modules/: dwm1000.cpp ethernetif.c lwip.c soc_proto.cpp
  group Application/Tasks
    ../Src/tasks/: tsk_udp_client.cpp
  group Application/User
    ../Src/: main.cpp stm32f2xx_hal_msp.c stm32f2xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_eth.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_spi.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c
  group Middlewares/Decawave/decadriver
    ../Middlewares/Third_Party/Decawave/decadriver/: deca_device.c deca_device_api.h deca_param_types.h deca_params_init.c deca_regs.h deca_types.h deca_version.h
  group Middlewares/Decawave/platform
    ../Middlewares/Third_Party/Decawave/platform/: deca_mutex.c deca_port.c deca_port.h deca_range_tables.c deca_sleep.c deca_spi.c deca_spi.h sleep.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c slipif.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
